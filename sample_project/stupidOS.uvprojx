# Keil uVision project stupidOS.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: tinyOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\Source\App;.\Source\Os
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Os
    ./Source/Os/: os_bitmap.c os_config.h os_lib.h os_list.c os_switch.c stupidOS.h stupidOS.c os_cpu.c os_time.c os_task.c
  group App
    ./Source/App/: app.c app.h
  group Main
    ./Source/: main.c
  group ReadMe
    ./Source/: readme.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
